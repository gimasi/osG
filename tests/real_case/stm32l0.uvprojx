# Keil uVision project stm32l0.uvprojx, settings and files
target BasicTracker_L071 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L071CZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32l0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OSG_HAS_CONFIG_FILE
  c include: .\include;..\..\all-in-one
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./src/: main.c
    ./include/: osgConfig.h boardDefines.h
    ../../all-in-one/: osg-all-in-one.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L071CZTx/STCubeGenerated/Src/: main.c stm32l0xx_it.c
    ./RTE/Device/STM32L071CZTx/STCubeGenerated/Inc/: stm32l0xx_it.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:STM32Cube HAL 1.10.0
