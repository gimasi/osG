# Keil uVision project first.uvprojx, settings and files
target STM32L4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UartA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\PACK\Keil\STM32L4xx_DFP\2.0.0\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\board\STM32\L4\include;..\..\..\board\STM32\L4\include\support;..\..\..\board\STM32\L4\include\board;..\..\..\board\include;..\..\..\board\include\board;..\..\..\board\include\board\drivers;..\..\..\osg\include;..\..\..\osg\include\osg;..\..\..\osg\include\osg\drivers;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Include
    ../../../osg/include/: osg.h
    ../../../osg/include/osg/: BaseHwDataTypes.h BaseHw.h osgDataTypes.h utils.h drivers.h
    ../../../osg/include/osg/utils/: Log.h CircularFifo.h
    ../../../osg/include/osg/drivers/: GpioDataTypes.h Gpio.h LedDataTypes.h Led.h ThreadDataTypes.h Thread.h TimerDataTypes.h Timer.h I2cDataTypes.h I2c.h SpiDataTypes.h Spi.h UartDataTypes.h Uart.h
    ../../../board/include/: board.h
    ../../../board/include/board/: board-forwards.h board-BaseHw.h board-drivers.h
    ../../../board/include/board/drivers/: board-Gpio.h board-Led.h board-Timer.h board-I2c.h board-Spi.h board-Uart.h
  group Source
    ./src/: main.c
    ../../../osg/src/utils/: Log.c CircularFifo.c
    ../../../osg/src/: BaseHw.c
    ../../../osg/src/drivers/: Gpio.c Led.c Thread.c Timer.c I2c.c Spi.c Uart.c
  group Board
    ../../../board/STM32/L4/include/board/: board-config.h stm32l4xx_hal_conf.h
    ../../../board/STM32/L4/src/: board-BaseHw.c
    ../../../board/STM32/L4/src/drivers/: board-Gpio.c board-Led.c board-Timer.c board-I2c.c board-Spi.c board-Uart.c
  group Drivers
    C:/Keil_v5/ARM/PACK/Keil/STM32L4xx_DFP/2.0.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.3.1
