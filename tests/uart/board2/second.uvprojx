# Keil uVision project second.uvprojx, settings and files
target NXP MK28F15 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK28FN2M0VMI15 NXP
  pack: NXP.MK28F15_DFP.10.0.3
  cpu: IRAM(0x1ffc0000,0x040000) IRAM2(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UartB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: C:\Keil_v5\ARM\PACK\NXP\MK28F15_DFP\10.0.3\drivers;..\..\..\board\NXP\MK28FN2M0VMI15\include;..\..\..\board\NXP\MK28FN2M0VMI15\include\board;..\..\..\board\include;..\..\..\board\include\board;..\..\..\board\include\board\drivers;..\..\..\osg\include;..\..\..\osg\include\osg;..\..\..\osg\include\osg\drivers;.\inc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffc0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\MK28FN2M0VMI15\MK28FN2M0xxx15_flash.scf
  group Include
    ../../../osg/include/: osg.h
    ../../../osg/include/osg/: BaseHwDataTypes.h BaseHw.h osgDataTypes.h utils.h drivers.h
    ../../../osg/include/osg/utils/: Log.h CircularFifo.h
    ../../../osg/include/osg/drivers/: GpioDataTypes.h Gpio.h LedDataTypes.h Led.h ThreadDataTypes.h Thread.h TimerDataTypes.h Timer.h I2cDataTypes.h I2c.h SpiDataTypes.h Spi.h UartDataTypes.h Uart.h
    ../../../board/include/: board.h
    ../../../board/include/board/: board-forwards.h board-BaseHw.h board-drivers.h
    ../../../board/include/board/drivers/: board-Gpio.h board-Led.h board-Timer.h board-I2c.h board-Spi.h board-Uart.h
  group Source
    ./src/: main.c
    ../../../osg/src/utils/: Log.c CircularFifo.c
    ../../../osg/src/: BaseHw.c
    ../../../osg/src/drivers/: Gpio.c Led.c Thread.c Timer.c I2c.c Spi.c Uart.c
  group Board
    ../../../board/NXP/MK28FN2M0VMI15/include/board/: board-config.h
    ../../../board/NXP/MK28FN2M0VMI15/src/: board-BaseHw.c
    ../../../board/NXP/MK28FN2M0VMI15/src/drivers/: board-Gpio.c board-Led.c board-Timer.c board-I2c.c board-Spi.c board-Uart.c
  group Drivers
    C:/Keil_v5/ARM/PACK/NXP/MK28F15_DFP/10.0.3/drivers/: fsl_clock.c fsl_common.c fsl_dmamux.c fsl_edma.c fsl_gpio.c fsl_i2c.c fsl_pit.c fsl_dspi.c fsl_lpuart.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
