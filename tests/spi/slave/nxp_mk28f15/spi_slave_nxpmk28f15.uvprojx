# Keil uVision project spi_slave_nxpmk28f15.uvprojx, settings and files
target NXPMK28F (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK28FN2M0VMI15 NXP
  pack: NXP.MK28F15_DFP.11.0.0
  cpu: IRAM(0x1ffc0000,0x040000) IRAM2(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_slave_nxpmk28f15
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OSG_HAS_CONFIG_FILE
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\all-in-one;.\include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffc0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\MK28FN2M0VMI15\MK28FN2M0xxx15_flash.scf
  group Sources
    ./include/: osgConfig.h
    ./src/: main.c
    ../../../../all-in-one/: osg-all-in-one.c
software components: CMSIS:CORE 5.1.2, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.1, Device:SDK Drivers:dspi 2.2.0, Device:SDK Drivers:gpio 2.3.1, Device:SDK Drivers:i2c 2.0.6, Device:SDK Drivers:lpuart 2.2.6, Device:SDK Drivers:pit 2.0.1, Device:SDK Drivers:port 2.1.0, Device:Startup:MK28F15_startup 1.0.0
