# Keil uVision project i2cSlave.uvprojx, settings and files
target STM32L4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2cSlave
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\PACK\Keil\STM32L4xx_DFP\2.1.0\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\board\STM32\L4\include;..\..\..\board\STM32\L4\include\support;..\..\..\board\STM32\L4\include\board;..\..\..\board\include;..\..\..\board\include\board;..\..\..\board\include\board\drivers;..\..\..\osg\include;..\..\..\osg\include\osg;..\..\..\osg\include\osg\drivers;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Include
    ../../../osg/include/: osg.h
    ../../../osg/include/osg/: BaseHwDataTypes.h BaseHw.h drivers.h osgDataTypes.h utils.h
    ../../../osg/include/osg/utils/: Log.h CircularFifo.h
    ../../../osg/include/osg/drivers/: GpioDataTypes.h Gpio.h LedDataTypes.h Led.h ThreadDataTypes.h Thread.h TimerDataTypes.h Timer.h I2cDataTypes.h I2c.h SpiDataTypes.h Spi.h UartDataTypes.h Uart.h
    ../../../board/include/: board.h
    ../../../board/include/board/: board-drivers.h board-forwards.h board-BaseHw.h
    ../../../board/include/board/drivers/: board-Gpio.h board-Led.h board-Timer.h board-I2c.h board-Spi.h board-Uart.h
  group Source
    ./src/: main.c
    ../../../osg/src/utils/: Log.c CircularFifo.c
    ../../../osg/src/: BaseHw.c
    ../../../osg/src/drivers/: Gpio.c Led.c Thread.c Timer.c I2c.c Uart.c Spi.c
  group Board STM32L4
    ../../../board/STM32/L4/include/board/: board-config.h stm32l4xx_hal_conf.h
    ../../../board/STM32/L4/src/: board-BaseHw.c
    ../../../board/STM32/L4/src/drivers/: board-Gpio.c board-Led.c board-Timer.c board-I2c.c board-Spi.c board-Uart.c
  group Board NXP MK28F
    ../../../board/NXP/MK28FN2M0VMI15/include/board/: board-config.h
    ../../../board/NXP/MK28FN2M0VMI15/src/: board-BaseHw.c
    ../../../board/NXP/MK28FN2M0VMI15/src/drivers/: board-Gpio.c board-Led.c board-Timer.c board-I2c.c board-Uart.c board-Spi.c
  group Drivers STM32L4
    C:/Keil_v5/ARM/PACK/Keil/STM32L4xx_DFP/2.1.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
  group Drivers NXP MK28F
    C:/Keil_v5/ARM/PACK/NXP/MK28F15_DFP/10.0.3/drivers/: fsl_clock.c fsl_common.c fsl_dmamux.c fsl_edma.c fsl_gpio.c fsl_i2c.c fsl_pit.c fsl_lpuart.c fsl_dspi.c
    C:/Keil_v5/ARM/PACK/NXP/MK28F15_DFP/10.0.3/template/: RTE_Device.h
target NXPMK28F (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK28FN2M0VMI15 NXP
  pack: NXP.MK28F15_DFP.10.0.3
  cpu: IRAM(0x1ffc0000,0x040000) IRAM2(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2cSlave
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: C:\Keil_v5\ARM\PACK\NXP\MK28F15_DFP\10.0.3\drivers;..\..\..\board\NXP\MK28FN2M0VMI15\include;..\..\..\board\NXP\MK28FN2M0VMI15\include\board;..\..\..\board\include;..\..\..\board\include\board;..\..\..\board\include\board\drivers;..\..\..\osg\include;..\..\..\osg\include\osg;..\..\..\osg\include\osg\drivers;..\..\..\osg\include\osg\utils;.\inc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffc0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\MK28FN2M0VMI15\MK28FN2M0xxx15_flash.scf
software components: CMSIS:CORE 5.1.2, Device:Startup 1.3.1, Device:Startup 1.0.0
