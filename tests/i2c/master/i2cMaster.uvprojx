# Keil uVision project i2cMaster.uvprojx, settings and files
target STM32L4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2cMaster
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OSG_HAS_CONFIG_FILE
  c include: ..\..\..\all-in-one;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Include
    ./inc/: osgConfig.h
  group Source
    ./src/: main.c
    ../../../all-in-one/: osg-all-in-one.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
target NXPMK28F (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK28FN2M0VMI15 NXP
  pack: NXP.MK28F15_DFP.11.0.0
  cpu: IRAM(0x1ffc0000,0x040000) IRAM2(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2cMaster
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OSG_HAS_CONFIG_FILE
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: C:\Keil_v5\ARM\PACK\NXP\MK28F15_DFP\11.0.0\drivers;..\..\..\all-in-one;.\inc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffc0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\MK28FN2M0VMI15\MK28FN2M0xxx15_flash.scf
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:Flash 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.3.1, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.1, Device:SDK Drivers:dspi 2.2.0, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.3.1, Device:SDK Drivers:i2c 2.0.6, Device:SDK Drivers:lpuart 2.2.6, Device:SDK Drivers:pit 2.0.1, Device:Startup:MK28F15_startup 1.0.0
